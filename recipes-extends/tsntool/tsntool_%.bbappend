COMPATIBLE_MACHINE:nxp-ls1028 = "nxp-ls1028"
SRCREV:nxp-ls1028 = "dbe0feb2bcf7bf2be2c009cf82398f9fee30ff89"
