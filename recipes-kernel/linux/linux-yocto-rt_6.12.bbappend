KBRANCH:nxp-ls1028  = "v6.12/standard/preempt-rt/nxp-sdk-6.12/nxp-soc"

require linux-yocto-nxp-ls1028.inc
