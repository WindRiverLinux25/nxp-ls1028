COMPATIBLE_MACHINE:nxp-ls1028 = "nxp-ls1028"
